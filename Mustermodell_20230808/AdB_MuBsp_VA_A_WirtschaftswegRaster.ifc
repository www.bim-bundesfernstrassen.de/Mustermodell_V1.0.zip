Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: 12345
Time: 2023-03-03T16:27:10
Author: BIM Deutschland
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200826_1250(x64) - Exporter 20.2.30.42 - Alternativ-UI 20.2.30.42
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 03 16:27:10 2023 * Host: SP-20221205 * Database: C:\Users\npauls\AppData\Local\Temp\f179f545-097f-417a-b5a9-f6832ab02ed7\c089a29b-6d60-4017-a5ee-f173bd9b4975\ifc * Database version: 5507 * Database creation date: Fri Mar 03 16:27:10 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 03 16:27:10 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 03 16:27:10 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 12345
LongName: Neubau Überführungsbauwerk im Zuge des Wirtschaftsweges 001 über die BAB 001

# IfcSite, Gemarkung E-Stadt
RefLatitude: 48, 7, 58, 797912; RefLongitude: 11, 34, 58, 800659; RefElevation: 0 m

# IfcBuilding, Überführungsbauwerk Wirtschaftsweg 001
LongName: Überführungsbauwerk Wirtschaftsweg 001
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Ebene:Ebene, Ebene 0
In: Überführungsbauwerk Wirtschaftsweg 001
LongName: BAB 001 +130.95; Elevation: 130.95 m
Pset_AirSideSystemInformation - Name: Ebene E0 +0.00; sets with these values: 2

# IfcBuildingElementProxy: Beschriftung10 (6)
In: Ebene 0
Type - Material: Rendermaterial 0-0-0, Rendermaterial 255-255-255
Type - Pset_BuildingElementProxyCommon - Reference: Beschriftung10
Type - Pset_QuantityTakeOff - Reference: Beschriftung10
Pset_BuildingElementProxyCommon - sets with these values: 2
Klassifizierung - Objektgruppe: Annotation; Objektklasse: Informationstext; Objekttyp: -
Baustoff - Baustoff: -
Lage - Abschnitt: Wirtschaftsweg; Bereich: Ueberfuehrungsbereich; Ebene: -; Achse: Achse 100A (RAB-ING_Musterbeispiel_6-2-1)
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: -
Name | StationierungVon (m) = StationierungBis (m)
Beschriftung10:Beschriftung10:2559363 | 277.815
Beschriftung1:Beschriftung10:2559390 | 251.315
Beschriftung2:Beschriftung10:2559417 | 224.815
Beschriftung3:Beschriftung10:2559443 | 277.815
Beschriftung4:Beschriftung10:2559524 | 251.315
Beschriftung5:Beschriftung10:2559566 | 224.815

# IfcBuildingElementProxy: BeschriftungRasterKM (3)
In: Ebene 0
Type - Material: Rendermaterial 255-255-255
Type - Pset_BuildingElementProxyCommon - Reference: BeschriftungRasterKM
Type - Pset_QuantityTakeOff - Reference: BeschriftungRasterKM
Pset_BuildingElementProxyCommon - sets with these values: 2
Klassifizierung - Objektgruppe: Annotation; Objektklasse: Informationstext; Objekttyp: -
Baustoff - Baustoff: -
Lage - Abschnitt: Wirtschaftsweg; Bereich: Ueberfuehrungsbereich; Ebene: -; Achse: Achse 100A (RAB-ING_Musterbeispiel_6-2-1)
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: -
Name | StationierungVon (m) = StationierungBis (m)
BeschriftungRasterKM:BeschriftungRasterKM:2563176 | 277.815
BeschriftungRasterKM1:BeschriftungRasterKM:2563538 | 251.315
BeschriftungRasterKM2:BeschriftungRasterKM:2563574 | 224.815

# IfcBuildingElementProxy: BeschriftungRasterV10 (3)
In: Ebene 0
Type - Material: Rendermaterial 255-255-255
Type - Pset_BuildingElementProxyCommon - Reference: BeschriftungRasterV10
Type - Pset_QuantityTakeOff - Reference: BeschriftungRasterV10
Pset_BuildingElementProxyCommon - sets with these values: 2
Klassifizierung - Objektgruppe: Annotation; Objektklasse: Informationstext; Objekttyp: -
Baustoff - Baustoff: -
Lage - Abschnitt: Wirtschaftsweg; Bereich: Ueberfuehrungsbereich; Ebene: -; Achse: Achse 100A (RAB-ING_Musterbeispiel_6-2-1)
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: -
Name | StationierungVon (m) = StationierungBis (m)
BeschriftungRasterV10:BeschriftungRasterV10:2564335 | 277.815
BeschriftungRasterV1:BeschriftungRasterV10:2564498 | 251.315
BeschriftungRasterV2:BeschriftungRasterV10:2564537 | 224.815

# IfcBuildingElementProxy: Modelltext:200 mm Arial (12)
In: Ebene 0
Pset_BuildingElementProxyCommon - Reference: 200 mm Arial; sets with these values: 2
Klassifizierung - Objektgruppe: Annotation; Objektklasse: Informationstext; Objekttyp: -
Baustoff - Baustoff: -
Lage - Abschnitt: Wirtschaftsweg; Bereich: Ueberfuehrungsbereich; Ebene: -; Achse: Achse 100A (RAB-ING_Musterbeispiel_6-2-1)
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: -
Name (Modelltext:200 mm Arial:...) | StationierungVon (m) = StationierungBis (m)
2563177 | 277.815
2563344 | 277.815
2563539 | 251.315
2563542 | 251.315
2563575 | 224.815
2563578 | 224.815
2564362 | 277.815
2564445 | 277.815
2564499 | 251.315
2564502 | 251.315
2564538 | 224.815
2564541 | 224.815

# IfcBuildingElementProxy: Modelltext:600 mm Arial (12)
In: Ebene 0
Pset_BuildingElementProxyCommon - Reference: 600 mm Arial; sets with these values: 2
Klassifizierung - Objektgruppe: Annotation; Objektklasse: Informationstext; Objekttyp: -
Baustoff - Baustoff: -
Lage - Abschnitt: Wirtschaftsweg; Bereich: Ueberfuehrungsbereich; Ebene: -; Achse: Achse 100A (RAB-ING_Musterbeispiel_6-2-1)
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: -
Name (Modelltext:600 mm Arial:...) | StationierungVon (m) = StationierungBis (m)
2559381 | 277.815
2559408 | 251.315
2559513 | 224.815
2559517 | 277.815
2559519 | 277.815
2559559 | 251.315
2559561 | 251.315
2559601 | 224.815
2559603 | 224.815
2559604 | 277.815
2559605 | 251.315
2559606 | 224.815
