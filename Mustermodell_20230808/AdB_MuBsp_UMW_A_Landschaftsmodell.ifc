Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
Time: 2023-03-01T12:47:54
Author: BIM Deutschland
Written by: ODA IFC SDK 22.8
Made in: 22.1.10.541 - Exporter 22.1.10.541 - Alternativ-UI 22.1.10.541

# IfcSite, Gemarkung E-Stadt
RefLatitude: 48, 7, 58, 797912; RefLongitude: 11, 34, 58, 800659; RefElevation: 0 m

# IfcBuilding, Überführungsbauwerk Wirtschaftsweg 001
LongName: Überführungsbauwerk Wirtschaftsweg 001
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Ebene:Ebene, OK Belag RQ +137.58
In: Überführungsbauwerk Wirtschaftsweg 001
LongName: OK Belag RQ +137.58; Elevation: 0 m
Pset_AirSideSystemInformation - Name: OK Belag RQ +137.58; sets with these values: 2

# IfcSpace: Schutzgebiet:Schutzgebiet, Schutzgebiet:Schutzgebiet:2502062
Type - Material: Umgebung
Pset_SpaceCommon - Reference: Schutzgebiet
Klassifizierung - Objektgruppe: Raum; Objektklasse: Tierschutzgebiet; Objekttyp: Fledermaus
Baustoff - Baustoff: -
Lage - Abschnitt: -; Bereich: Nordost; Ebene: -; Achse: -
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: Bestand

# IfcSpace: SchutzgebietWald:SchutzgebietWald, SchutzgebietWald:SchutzgebietWald:2502435
Type - Material: Umgebung
Pset_SpaceCommon - Reference: SchutzgebietWald
Klassifizierung - Objektgruppe: Raum; Objektklasse: Biotop; Objekttyp: Wald
Baustoff - Baustoff: -
Lage - Abschnitt: -; Bereich: Suedost; Ebene: -; Achse: -
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: Bestand

# IfcBuildingElementProxy: Baumkrone:Baumkrone (12)
In: OK Belag RQ +137.58
Type - Material: Holz - Eiche, Umgebung - Baum
Material: Umgebung - Baum
Pset_BuildingElementProxyCommon - Reference: Baumkrone; sets with these values: 2
Klassifizierung - Objektgruppe: Vegetation; Objektklasse: Baum; Objekttyp: Baumkrone
Baustoff - Baustoff: -
Lage - Abschnitt: -; Bereich: Suedost; Ebene: -; Achse: -
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: Bestand
Name (Baumkrone:Baumkrone:...)
2505473
2505480
2505501
2505506
2505524
2505531
2505538
2505661
2505669
2505686
2505694
2505704

# IfcBuildingElementProxy: Baumkrone:Baumkrone (7)
In: OK Belag RQ +137.58
Type - Material: Umgebung - Baum, Holz - Eiche
Material: Umgebung - Baum
Pset_BuildingElementProxyCommon - Reference: Baumkrone; sets with these values: 2
Klassifizierung - Objektgruppe: Vegetation; Objektklasse: Baum; Objekttyp: Baumkrone
Baustoff - Baustoff: -
Lage - Abschnitt: -; Bereich: Suedost; Ebene: -; Achse: -
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: Bestand
Name (Baumkrone:Baumkrone:...)
2505465
2505492
2505513
2505602
2505614
2505633
2505642

# IfcBuildingElementProxy: Baumstamm:Baumstamm (14)
In: OK Belag RQ +137.58
Type - Material: Holz - Eiche
Pset_BuildingElementProxyCommon - Reference: Baumstamm; sets with these values: 2
Klassifizierung - Objektgruppe: Vegetation; Objektklasse: Baum; Objekttyp: Baumstamm
Baustoff - Baustoff: -
Lage - Abschnitt: -; Bereich: Suedost; Ebene: -; Achse: -
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: Bestand
Name (Baumstamm:Baumstamm:...) | Depth (m)
2509249 | 8.5
2509251 | 7.5
2509252 | 7.5
2509253 | 9
2509254 | 7
2509255 | 7
2509256 | 8.5
2509257 | 7
2509258 | 7.5
2509259 | 7.5
2509260 | 9
2509263 | 8.5
2509266 | 7.5
2509267 | 7.5

# IfcBuildingElementProxy: Baumstamm:Baumstamm (2)
In: OK Belag RQ +137.58
Type - Material: Holz - Eiche, Umgebung - Baum
Material: Holz - Eiche
Pset_BuildingElementProxyCommon - Reference: Baumstamm; sets with these values: 2
Klassifizierung - Objektgruppe: Vegetation; Objektklasse: Baum; Objekttyp: Baumstamm
Baustoff - Baustoff: -
Lage - Abschnitt: -; Bereich: Suedost; Ebene: -; Achse: -
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: Bestand
Name (Baumstamm:Baumstamm:...)
2509265
2509268

# IfcBuildingElementProxy: Baumstamm:Baumstamm (3)
In: OK Belag RQ +137.58
Type - Material: Umgebung - Baum, Holz - Eiche
Material: Holz - Eiche
Pset_BuildingElementProxyCommon - Reference: Baumstamm; sets with these values: 2
Klassifizierung - Objektgruppe: Vegetation; Objektklasse: Baum; Objekttyp: Baumstamm
Baustoff - Baustoff: -
Lage - Abschnitt: -; Bereich: Suedost; Ebene: -; Achse: -
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: Bestand
Name (Baumstamm:Baumstamm:...)
2509261
2509262
2509264
