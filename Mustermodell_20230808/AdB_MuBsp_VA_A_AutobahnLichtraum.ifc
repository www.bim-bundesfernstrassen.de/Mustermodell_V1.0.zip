Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: AutobahnLichtraum.ifc
Time: 2023-03-03T09:35:59
Written by: IfcEngine 1032
Made in: ProVI
Comment: General definitions
Comment: Global X direction
Comment: Global Y direction
Comment: Global Z direction
Comment: Global origin
Comment: IfcOwnerHistory contain information about the person and organization
Comment: that produced this file
Comment: IfcProject is the top most element in the project structure
Comment: IfcUnitAssignment defines the global units for measures and values
Comment: when the units are not otherwise defined
Comment: IfcGeometricRepresentationContext is the global context of the data
Comment: MSI ePSet linked to ifcProject with information about the underlying
Comment: geodetic coordinate reference system
Comment: MSI ePSet linked to ifcProject with information about the global-to-local
Comment: transformation
Comment: IfcSite is the top most element in the spatial structure
Comment: There must be at least 1 IfcBuilding in the file
Comment: Container for all storeys within IFCBUILDING(#50)

# IfcProject, MuBsp_AdB
ePSet_ProjectedCRS - Name: Unbekanntes Bezugssystem
ePSet_MapConversion - Eastings: 0 m; Northings: 0 m; OrthogonalHeight: 0 m; XAxisAbscissa: 1; XAxisOrdinate: 0; Scale: 1

# IfcBuilding
ElevationOfRefHeight: 0 m

# IfcBuildingStorey, Lichtraum
Elevation: 0 m

# IfcBuildingElementProxy (8)
In: Lichtraum
Bauphase - Bauzustand: Neubau; BauphaseStart: 1; BauphaseEnde: 2
Baustoff - Baustoff: -
Klassifizierung - Objektklasse: Lichtraum; Objektgruppe: Raum; Objekttyp: Lichtraumprofil
Lage - Abschnitt: Bundesautobahn; Ebene: -; Achse: Achse 200A (Autobahn)
Name | StationierungVon (m) | StationierungBis (m) | Bereich
2 x Lichtraum | 670958 | 671000 | Norden
2 x Lichtraum | 671000 | 671050 | Norden
2 x Lichtraum | 671050 | 671100 | Sueden
2 x Lichtraum | 671100 | 671144 | Sueden
