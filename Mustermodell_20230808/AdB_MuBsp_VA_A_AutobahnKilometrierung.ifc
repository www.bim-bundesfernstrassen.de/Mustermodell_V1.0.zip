Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: 12345
Time: 2023-03-03T16:22:16
Author: BIM Deutschland
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200826_1250(x64) - Exporter 20.2.30.42 - Alternativ-UI 20.2.30.42
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 03 16:22:16 2023 * Host: SP-20221205 * Database: C:\Users\npauls\AppData\Local\Temp\f179f545-097f-417a-b5a9-f6832ab02ed7\b0d910b5-740e-43ae-8e4b-2db6a2c2fbf3\ifc * Database version: 5507 * Database creation date: Fri Mar 03 16:22:14 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 03 16:22:14 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 03 16:22:14 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 12345
LongName: Neubau Überführungsbauwerk im Zuge des Wirtschaftsweges 001 über die BAB 001

# IfcSite, Gemarkung E-Stadt
RefLatitude: 48, 7, 58, 797912; RefLongitude: 11, 34, 58, 800659; RefElevation: 0 m

# IfcBuilding, Überführungsbauwerk Wirtschaftsweg 001
LongName: Überführungsbauwerk Wirtschaftsweg 001
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Ebene:Ebene, Ebene 0
In: Überführungsbauwerk Wirtschaftsweg 001
LongName: BAB 001 +130.95; Elevation: 130.95 m
Pset_AirSideSystemInformation - Name: Ebene E0 +0.00; sets with these values: 2

# IfcBuildingElementProxy: Beschriftung10 (4)
In: Ebene 0
Type - Material: Rendermaterial 0-0-0, Rendermaterial 255-255-255
Type - Pset_BuildingElementProxyCommon - Reference: Beschriftung10
Type - Pset_QuantityTakeOff - Reference: Beschriftung10
Pset_BuildingElementProxyCommon - sets with these values: 2
Klassifizierung - Objektgruppe: Annotation; Objektklasse: Informationstext; Objekttyp: -
Baustoff - Baustoff: -
Lage - Abschnitt: Bundesautobahn; Ebene: -; Achse: Achse 200A (Autobahn)
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: -
Name | Bereich | StationierungVon (m) = StationierungBis (m)
Beschriftung9:Beschriftung10:2559807 | Sueden | 1143.96
Beschriftung11:Beschriftung10:2568306 | Sueden | 1100
Beschriftung12:Beschriftung10:2568428 | Norden | 1000
Beschriftung13:Beschriftung10:2568547 | Norden | 958.26

# IfcBuildingElementProxy: Modelltext:600 mm Arial (12)
In: Ebene 0
Pset_BuildingElementProxyCommon - Reference: 600 mm Arial; sets with these values: 2
Klassifizierung - Objektgruppe: Annotation; Objektklasse: Informationstext; Objekttyp: -
Baustoff - Baustoff: -
Lage - Abschnitt: Bundesautobahn; Ebene: -; Achse: Achse 200A (Autobahn)
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: -
Name (Modelltext:600 mm Arial:...) | Bereich | StationierungVon (m) = StationierungBis (m)
2559864 | Sueden | 1143.96
2559866 | Sueden | 1143.96
2568070 | Sueden | 1143.96
2568357 | Sueden | 1100
2568359 | Sueden | 1100
2568400 | Sueden | 1100
2568479 | Norden | 1000
2568481 | Norden | 1000
2568522 | Norden | 1000
2568598 | Norden | 958.26
2568600 | Norden | 958.26
2568641 | Norden | 958.26
