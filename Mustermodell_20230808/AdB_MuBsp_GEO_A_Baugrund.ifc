Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010, QuantityTakeOffAddOnView, SpaceBoundary1stLevelAddOnView], ExchangeRequirement[Architecture], Option [ExcludedObjects: , , , , , , , , , , , , , , , , , , , ,]
Time: 2023-03-28T12:31:04
Author: npauls
Written by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016
Made in: Autodesk Civil 3D 2022 - Deutsch (German) Build 13.4.214.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 28 12:31:04 2023 * Host: SP-20221205 * Database: C:\Users\npauls\AppData\Local\Temp\ACAIFCTMP/EDM16792\aec_ifc_db * Database version: 5507 * Database creation date: Tue Mar 28 08:55:20 2023 * Schema: IFC2X3 * Model: DataRepository.AecIfc * Model creation date: Tue Mar 28 12:31:04 2023 * Header model: DataRepository.AecIfc_Header * Header model creation date: Tue Mar 28 12:31:04 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5649 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0000
LongName: DGM_MuBsp_Endzustand_Volumen_Mrz
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcBuilding, DGM_MuBsp_Endzustand_Volumen_Mrz
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
BaseQuantities - Height: 0 m; NetFootprintArea: 0 m2; GrossFootprintArea: 0 m2; NetFloorArea: 0 m2; GrossFloorArea: 0 m2; GrossVolume: 0 m3

# IfcBuildingElementProxy (5)
In: DGM_MuBsp_Endzustand_Volumen_Mrz
Baustoff - Baustoff: Erde
Klassifizierung - Objektgruppe: Erdkoerper; Objekttyp: -
Lage - Ebene: -; Achse: -
Name | Bauzustand | BauphaseStart | BauphaseEnde | Objektklasse | Abschnitt | Bereich
 | Abbruch | 0 | 1 | Aushub | Bundesautobahn | -
3 x  | Abbruch | 3 | 2 | Aushub | Wirtschaftsweg | Ueberfuehrungsbereich
 | Bestand | - | - | Gelaende | - | -
