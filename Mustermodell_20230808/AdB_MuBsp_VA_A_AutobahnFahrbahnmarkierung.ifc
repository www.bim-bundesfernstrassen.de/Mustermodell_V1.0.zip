Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView]
File name: AdB_MuBsp_VA_A_AutobahnFahrbahnmarkierung.ifc
Time: 2023-02-24T16:31:26
Author: npauls
Organization: thinkproject Deutschland GmbH
Written by: IFC Engine DLL
Made in: DESITE md pro 3.0.2
Authorization: npauls

# IfcBuilding, _pMa3D
Description: Markierungen Schicht pMa3D
C1_Attribute - CARD_MARKIERUNG.LA_Bauwerk.LA_Fachmodell: Markierung; CARD_MARKIERUNG.LA_Bauwerk.LA_Modellierungsverfahren: Bauwerke Topografie

# IfcBuildingStorey (8)
In: _pMa3D
C1_Attribute - CARD_ATTR.LA_Fachinfo.LA_Material: Farbe; CARD_ATTR.LA_Fachinfo.LA_Datum_Attributierung: 06.02.23; CARD_MARKIERUNG.LA_Geometrie.LA_Laenge_Gesamt: 185,7000; CARD_ATTR.LA_Fachinfo.LA_Datum_Vermessung: --.--.--; CARD_MARKIERUNG.LA_Bauwerk.LA_Material: neutral_weiß; CARD_MARKIERUNG.LA_Bauwerk.LA_Art: Markierung; CARD_MARKIERUNG.LA_Bauwerk.LA_Card_1_Typ: Markierung; CARD_ATTR.LA_Fachinfo.LA_Ausführend_Attributierung: jhager; CARD_ATTR.LA_Fachinfo.LA_Typ: Markierung; CARD_ATTR.LA_Fachinfo.LA_Breite: 0,0000; CARD_MARKIERUNG.LA_Geometrie.LA_Linien_Elemente: 42
Name | CARD_MARKIERUNG.LA_Bauwerk.LA_Kode = CARD_ATTR.LA_Fachinfo.LA_Katalog_Kode | CARD_ATTR.LA_Fachinfo.LA_Katalog_Typ | CARD_MARKIERUNG.LA_Geometrie.LA_Strich_Breite | CARD_MARKIERUNG.LA_Bauwerk.LA_Typ | CARD_ATTR.LA_Fachinfo.LA_cpiFitMatchKey | CARD_MARKIERUNG.LA_Geometrie.LA_Strich_Abstand | CARD_MARKIERUNG.LA_Geometrie.LA_Strich_Laenge
30_B_rechts_001 | 8301R | MABreit_R | 0,3000 | 30_B_rechts | 8.131.1.911 | 0,0001 | 1,0000
30_B_links_002 | 8301L | MABreit_L | 0,3000 | 30_B_links | 8.131.1.911 | 0,0001 | 1,0000
15_S-6-12_003 | 8154 | MALeitlinie | 0,1500 | 15_S-6-12 | 8.131.1.910 | 12,0000 | 6,0000
15_S-6-12_004 | 8154 | MALeitlinie | 0,1500 | 15_S-6-12 | 8.131.1.910 | 12,0000 | 6,0000
15_S-6-12_005 | 8154 | MALeitlinie | 0,1500 | 15_S-6-12 | 8.131.1.910 | 12,0000 | 6,0000
15_S-6-12_006 | 8154 | MALeitlinie | 0,1500 | 15_S-6-12 | 8.131.1.910 | 12,0000 | 6,0000
30_B_links_007 | 8301L | MABreit_L | 0,3000 | 30_B_links | 8.131.1.911 | 0,0001 | 1,0000
30_B_rechts_008 | 8301R | MABreit_R | 0,3000 | 30_B_rechts | 8.131.1.911 | 0,0001 | 1,0000

# IfcBuildingElementProxy (12)
Material: card_1:neutral_weiß
Bauphase - BauphaseEnde: 2; Bauzustand: Neubau; BauphaseStart: 1
Baustoff - Baustoff: Farbe
Klassifizierung - Objektklasse: Fahrbahnmarkierung; Objektgruppe: Ausstattung; Objekttyp: -
Lage - Bereich: -; Ebene: -; Abschnitt: Bundesautobahn; Achse: -
Name | In | CARD_MARKIERUNG.LA_Geometrie.LA_Laenge_Bauteil_Markierung | CARD_MARKIERUNG.LA_Geometrie.LA_Laenge_Bauteil | CARD_MARKIERUNG.LA_Bauwerk.LA_Card_1_Typ | CARD_MARKIERUNG.LA_Geometrie.LA_Bauteil_Nr
30_B_rechts_1_1 | 30_B_rechts_001 | 101,0101 | 101,0101 | Längsmarkierung | 1
30_B_rechts_1_2 | 30_B_rechts_001 | 84,6900 | 84,6900 | Markierung allg. | 2
30_B_links_2_1 | 30_B_links_002 | 101,0101 | 101,0101 | Längsmarkierung | 1
30_B_links_2_2 | 30_B_links_002 | 84,6900 | 84,6900 | Markierung allg. | 2
15_S-6-12_3_1 | 15_S-6-12_003 | 65,7000 | 185,7000 | Markierung allg. | 1
15_S-6-12_4_1 | 15_S-6-12_004 | 65,7000 | 185,7000 | Markierung allg. | 1
15_S-6-12_5_1 | 15_S-6-12_005 | 65,7000 | 185,7000 | Markierung allg. | 1
15_S-6-12_6_1 | 15_S-6-12_006 | 65,7000 | 185,7000 | Markierung allg. | 1
30_B_links_7_1 | 30_B_links_007 | 101,0101 | 101,0101 | Längsmarkierung | 1
30_B_links_7_2 | 30_B_links_007 | 84,6900 | 84,6900 | Markierung allg. | 2
30_B_rechts_8_1 | 30_B_rechts_008 | 101,0101 | 101,0101 | Längsmarkierung | 1
30_B_rechts_8_2 | 30_B_rechts_008 | 84,6900 | 84,6900 | Markierung allg. | 2
