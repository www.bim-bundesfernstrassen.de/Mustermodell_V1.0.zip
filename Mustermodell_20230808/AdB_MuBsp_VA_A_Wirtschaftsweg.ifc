Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: WW_VA.ifc
Time: 2023-03-01T15:24:27
Written by: IfcEngine 1032
Made in: ProVI
Comment: General definitions
Comment: Global X direction
Comment: Global Y direction
Comment: Global Z direction
Comment: Global origin
Comment: IfcOwnerHistory contain information about the person and organization
Comment: that produced this file
Comment: IfcProject is the top most element in the project structure
Comment: IfcUnitAssignment defines the global units for measures and values
Comment: when the units are not otherwise defined
Comment: IfcGeometricRepresentationContext is the global context of the data
Comment: MSI ePSet linked to ifcProject with information about the underlying
Comment: geodetic coordinate reference system
Comment: MSI ePSet linked to ifcProject with information about the global-to-local
Comment: transformation
Comment: IfcSite is the top most element in the spatial structure
Comment: There must be at least 1 IfcBuilding in the file
Comment: Container for all storeys within IFCBUILDING(#50)

# IfcProject, MuBsp_AdB
ePSet_ProjectedCRS - Name: Unbekanntes Bezugssystem
ePSet_MapConversion - Eastings: 0 m; Northings: 0 m; OrthogonalHeight: 0 m; XAxisAbscissa: 1; XAxisOrdinate: 0; Scale: 1

# IfcBuilding
ElevationOfRefHeight: 0 m

# IfcBuildingStorey (6)
Elevation: 0 m
Name
Erdauftrag
Asphalt
Schotter
Füllmassen
Mutterbodenauftrag
Leitpfosten

# IfcBuildingElementProxy (50)
Bauphase - Bauzustand: Neubau
Lage - Abschnitt: Wirtschaftsweg; Ebene: -; Achse: Achse 100A (RAB-ING_Musterbeispiel_6-2-1)
Name | In | BauphaseStart | BauphaseEnde | Baustoff | Objektklasse | Objekttyp | Objektgruppe | StationierungVon (m) | StationierungBis (m) | Bereich
Erdauftrag | Erdauftrag | 5 | 6 | Erde | Damm | - | Erdkoerper | 158.465 | 200 | Osten
Erdauftrag | Erdauftrag | 5 | 6 | Erde | Damm | - | Erdkoerper | 200 | 208.464 | Osten
Erdauftrag | Erdauftrag | 5 | 6 | Erde | Damm | - | Erdkoerper | 294.166 | 300 | Westen
Erdauftrag | Erdauftrag | 5 | 6 | Erde | Damm | - | Erdkoerper | 300 | 344.164 | Westen
Asphalt | Asphalt | 6 | 7 | Asphalt | Aufbauschicht | Deckschicht | Fahrbahnschicht | 158.465 | 200 | Osten
Asphalt | Asphalt | 6 | 7 | Asphalt | Aufbauschicht | Deckschicht | Fahrbahnschicht | 200 | 208.465 | Osten
Asphalt | Asphalt | 6 | 7 | Asphalt | Aufbauschicht | Deckschicht | Fahrbahnschicht | 208.465 | 224.264 | Osten
Asphalt | Asphalt | 6 | 7 | Asphalt | Aufbauschicht | Deckschicht | Fahrbahnschicht | 278.365 | 294.165 | Westen
Asphalt | Asphalt | 6 | 7 | Asphalt | Aufbauschicht | Deckschicht | Fahrbahnschicht | 294.165 | 300 | Westen
Asphalt | Asphalt | 6 | 7 | Asphalt | Aufbauschicht | Deckschicht | Fahrbahnschicht | 300 | 344.164 | Westen
Schotter | Schotter | 5 | 6 | Schotter | Aufbauschicht | Frostschutzschicht | Fahrbahnschicht | 158.465 | 200 | Osten
Schotter | Schotter | 5 | 6 | Schotter | Aufbauschicht | Frostschutzschicht | Fahrbahnschicht | 200 | 208.464 | Osten
Schotter | Schotter | 5 | 6 | Schotter | Aufbauschicht | Frostschutzschicht | Fahrbahnschicht | 294.165 | 300 | Westen
Schotter | Schotter | 5 | 6 | Schotter | Aufbauschicht | Frostschutzschicht | Fahrbahnschicht | 300 | 344.164 | Westen
2 x Füllmassen | Füllmassen | 5 | 6 | Erde | Bankettverfuellung | - | Erdkoerper | 158.465 | 200 | Osten
2 x Füllmassen | Füllmassen | 5 | 6 | Erde | Bankettverfuellung | - | Erdkoerper | 200 | 208.464 | Osten
2 x Füllmassen | Füllmassen | 5 | 6 | Erde | Bankettverfuellung | - | Erdkoerper | 294.166 | 300 | Westen
2 x Füllmassen | Füllmassen | 5 | 6 | Erde | Bankettverfuellung | - | Erdkoerper | 300 | 344.164 | Westen
2 x Mutterbodenauftrag | Mutterbodenauftrag | 5 | 6 | Mutterboden | Oberboden | - | Erdkoerper | 158.465 | 200 | Osten
2 x Mutterbodenauftrag | Mutterbodenauftrag | 5 | 6 | Mutterboden | Oberboden | - | Erdkoerper | 200 | 208.464 | Osten
2 x Mutterbodenauftrag | Mutterbodenauftrag | 5 | 6 | Mutterboden | Oberboden | - | Erdkoerper | 294.166 | 300 | Westen
2 x Mutterbodenauftrag | Mutterbodenauftrag | 5 | 6 | Mutterboden | Oberboden | - | Erdkoerper | 300 | 344.164 | Westen
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 160 | 160 | Osten | ProVI - PVI_BEZEICHNUNG: Leitpfosten links; PVI_KM_VON: 0+160.000; PVI_KM_BIS: 0+160.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 170 | 170 | Osten | ProVI - PVI_BEZEICHNUNG: Leitpfosten links; PVI_KM_VON: 0+170.000; PVI_KM_BIS: 0+170.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 180 | 180 | Osten | ProVI - PVI_BEZEICHNUNG: Leitpfosten links; PVI_KM_VON: 0+180.000; PVI_KM_BIS: 0+180.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 190 | 190 | Osten | ProVI - PVI_BEZEICHNUNG: Leitpfosten links; PVI_KM_VON: 0+190.000; PVI_KM_BIS: 0+190.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 200 | 200 | Osten | ProVI - PVI_BEZEICHNUNG: Leitpfosten links; PVI_KM_VON: 0+200.000; PVI_KM_BIS: 0+200.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 300 | 300 | Westen | ProVI - PVI_BEZEICHNUNG: Leitpfosten links; PVI_KM_VON: 0+300.000; PVI_KM_BIS: 0+300.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 310 | 310 | Westen | ProVI - PVI_BEZEICHNUNG: Leitpfosten links; PVI_KM_VON: 0+310.000; PVI_KM_BIS: 0+310.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 320 | 320 | Westen | ProVI - PVI_BEZEICHNUNG: Leitpfosten links; PVI_KM_VON: 0+320.000; PVI_KM_BIS: 0+320.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 330 | 330 | Westen | ProVI - PVI_BEZEICHNUNG: Leitpfosten links; PVI_KM_VON: 0+330.000; PVI_KM_BIS: 0+330.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 340 | 340 | Westen | ProVI - PVI_BEZEICHNUNG: Leitpfosten links; PVI_KM_VON: 0+340.000; PVI_KM_BIS: 0+340.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 160 | 160 | Osten | ProVI - PVI_BEZEICHNUNG: Leitpfosten rechts; PVI_KM_VON: 0+160.000; PVI_KM_BIS: 0+160.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 170 | 170 | Osten | ProVI - PVI_BEZEICHNUNG: Leitpfosten rechts; PVI_KM_VON: 0+170.000; PVI_KM_BIS: 0+170.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 180 | 180 | Osten | ProVI - PVI_BEZEICHNUNG: Leitpfosten rechts; PVI_KM_VON: 0+180.000; PVI_KM_BIS: 0+180.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 190 | 190 | Osten | ProVI - PVI_BEZEICHNUNG: Leitpfosten rechts; PVI_KM_VON: 0+190.000; PVI_KM_BIS: 0+190.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 200 | 200 | Osten | ProVI - PVI_BEZEICHNUNG: Leitpfosten rechts; PVI_KM_VON: 0+200.000; PVI_KM_BIS: 0+200.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 300 | 300 | Westen | ProVI - PVI_BEZEICHNUNG: Leitpfosten rechts; PVI_KM_VON: 0+300.000; PVI_KM_BIS: 0+300.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 310 | 310 | Westen | ProVI - PVI_BEZEICHNUNG: Leitpfosten rechts; PVI_KM_VON: 0+310.000; PVI_KM_BIS: 0+310.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 320 | 320 | Westen | ProVI - PVI_BEZEICHNUNG: Leitpfosten rechts; PVI_KM_VON: 0+320.000; PVI_KM_BIS: 0+320.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 330 | 330 | Westen | ProVI - PVI_BEZEICHNUNG: Leitpfosten rechts; PVI_KM_VON: 0+330.000; PVI_KM_BIS: 0+330.000
Leitpfosten | Leitpfosten | 6 | 7 | - | Leitpfosten | - | Schutzeinrichtung | 340 | 340 | Westen | ProVI - PVI_BEZEICHNUNG: Leitpfosten rechts; PVI_KM_VON: 0+340.000; PVI_KM_BIS: 0+340.000
