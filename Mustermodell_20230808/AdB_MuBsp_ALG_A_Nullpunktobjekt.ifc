Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: 12345
Time: 2023-03-03T16:46:38
Author: BIM Deutschland
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200826_1250(x64) - Exporter 20.2.30.42 - Alternativ-UI 20.2.30.42
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 03 16:46:38 2023 * Host: SP-20221205 * Database: C:\Users\npauls\AppData\Local\Temp\f179f545-097f-417a-b5a9-f6832ab02ed7\f19e44c2-e777-490d-aa7a-5af1e6ebe3cc\ifc * Database version: 5507 * Database creation date: Fri Mar 03 16:46:37 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 03 16:46:37 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 03 16:46:37 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 12345
LongName: Neubau Überführungsbauwerk im Zuge des Wirtschaftsweges 001 über die BAB 001

# IfcSite, Gemarkung E-Stadt
RefLatitude: 48, 7, 58, 797912; RefLongitude: 11, 34, 58, 800659; RefElevation: 0 m

# IfcBuilding, Überführungsbauwerk Wirtschaftsweg 001
LongName: Überführungsbauwerk Wirtschaftsweg 001
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Ebene:Ebene, Ebene 0
In: Überführungsbauwerk Wirtschaftsweg 001
LongName: BAB 001 +130.95; Elevation: 130.95 m
Pset_AirSideSystemInformation - Name: Ebene E0 +0.00; sets with these values: 2

# IfcBuildingElementProxy: Kritischer Punkt, Kritischer Punkt1:Kritischer Punkt:2578564
In: Ebene 0
Type - Material: Rendermaterial 0-0-0, Rendermaterial 255-255-255
Type - Pset_BuildingElementProxyCommon - Reference: Kritischer Punkt
Type - Pset_QuantityTakeOff - Reference: Kritischer Punkt
Pset_BuildingElementProxyCommon - sets with these values: 2
Klassifizierung - Objektgruppe: Annotation; Objektklasse: Nullpunktobjekt; Objekttyp: Projektnullpunkt
Baustoff - Baustoff: -
Lage - Abschnitt: -; Bereich: -; Ebene: -; Achse: -
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: -

# IfcBuildingElementProxy: KritischerPunktBeschriftung, KritischerPunktBeschriftung:KritischerPunktBeschriftung:2578628
In: Ebene 0
Type - Material: Rendermaterial 0-0-0, Rendermaterial 255-255-255
Type - Pset_BuildingElementProxyCommon - Reference: KritischerPunktBeschriftung
Type - Pset_QuantityTakeOff - Reference: KritischerPunktBeschriftung
Pset_BuildingElementProxyCommon - sets with these values: 2
Klassifizierung - Objektgruppe: Annotation; Objektklasse: Nullpunktobjekt; Objekttyp: Projektnullpunkt
Baustoff - Baustoff: -
Lage - Abschnitt: -; Bereich: -; Ebene: -; Achse: -
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: -

# IfcBuildingElementProxy: Modelltext:600 mm Arial (7)
In: Ebene 0
Pset_BuildingElementProxyCommon - Reference: 600 mm Arial; sets with these values: 2
Klassifizierung - Objektgruppe: Annotation; Objektklasse: Nullpunktobjekt; Objekttyp: Projektnullpunkt
Baustoff - Baustoff: -
Lage - Abschnitt: -; Bereich: -; Ebene: -; Achse: -
Bauphase - BauphaseStart: -; BauphaseEnde: -; Bauzustand: -
Name (Modelltext:600 mm Arial:...)
2582595
2582596
2582624
2582677
2582704
2582728
2582747
