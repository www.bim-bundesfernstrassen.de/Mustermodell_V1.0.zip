Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Autobahn.ifc
Time: 2023-03-01T17:54:24
Written by: IfcEngine 1032
Made in: ProVI
Comment: General definitions
Comment: Global X direction
Comment: Global Y direction
Comment: Global Z direction
Comment: Global origin
Comment: IfcOwnerHistory contain information about the person and organization
Comment: that produced this file
Comment: IfcProject is the top most element in the project structure
Comment: IfcUnitAssignment defines the global units for measures and values
Comment: when the units are not otherwise defined
Comment: IfcGeometricRepresentationContext is the global context of the data
Comment: MSI ePSet linked to ifcProject with information about the underlying
Comment: geodetic coordinate reference system
Comment: MSI ePSet linked to ifcProject with information about the global-to-local
Comment: transformation
Comment: IfcSite is the top most element in the spatial structure
Comment: There must be at least 1 IfcBuilding in the file
Comment: Container for all storeys within IFCBUILDING(#50)

# IfcProject, MuBsp_AdB
ePSet_ProjectedCRS - Name: Unbekanntes Bezugssystem
ePSet_MapConversion - Eastings: 0 m; Northings: 0 m; OrthogonalHeight: 0 m; XAxisAbscissa: 1; XAxisOrdinate: 0; Scale: 1

# IfcBuilding
ElevationOfRefHeight: 0 m

# IfcBuildingStorey (11)
Elevation: 0 m
Name
Asphalt
Asphaltbinderschicht
Asphalttragschicht
Schottertragschicht
Schotter
Füllmassen
Mutterbodenauftrag
MuldenVolumen
Distanzschutzplanke
Schacht
Haltung

# IfcBuildingElementProxy (458)
Bauphase - Bauzustand: Neubau; BauphaseStart: 1; BauphaseEnde: 2
Lage - Abschnitt: Bundesautobahn; Ebene: -; Achse: Achse 200A (Autobahn)
Name | In | Baustoff | Objektklasse | Objekttyp | Objektgruppe | StationierungVon (m) | StationierungBis (m) | Bereich | PVI_BEZEICHNUNG | PVI_KM_VON = PVI_KM_BIS
2 x Asphalt | Asphalt | Asphalt | Aufbauschicht | Deckschicht | Fahrbahnschicht | 670958 | 671000 | Norden
2 x Asphalt | Asphalt | Asphalt | Aufbauschicht | Deckschicht | Fahrbahnschicht | 671000 | 671050 | Norden
2 x Asphalt | Asphalt | Asphalt | Aufbauschicht | Deckschicht | Fahrbahnschicht | 671050 | 671100 | Sueden
2 x Asphalt | Asphalt | Asphalt | Aufbauschicht | Deckschicht | Fahrbahnschicht | 671100 | 671144 | Sueden
2 x Asphaltbinderschicht | Asphaltbinderschicht | Asphaltbinderschicht | Aufbauschicht | Binderschicht | Fahrbahnschicht | 670958 | 671000 | Norden
2 x Asphaltbinderschicht | Asphaltbinderschicht | Asphaltbinderschicht | Aufbauschicht | Binderschicht | Fahrbahnschicht | 671000 | 671050 | Norden
2 x Asphaltbinderschicht | Asphaltbinderschicht | Asphaltbinderschicht | Aufbauschicht | Binderschicht | Fahrbahnschicht | 671050 | 671100 | Sueden
2 x Asphaltbinderschicht | Asphaltbinderschicht | Asphaltbinderschicht | Aufbauschicht | Binderschicht | Fahrbahnschicht | 671100 | 671144 | Sueden
2 x Asphalttragschicht | Asphalttragschicht | Asphalttragschicht | Aufbauschicht | Tragschicht | Fahrbahnschicht | 670958 | 671000 | Norden
2 x Asphalttragschicht | Asphalttragschicht | Asphalttragschicht | Aufbauschicht | Tragschicht | Fahrbahnschicht | 671000 | 671050 | Norden
2 x Asphalttragschicht | Asphalttragschicht | Asphalttragschicht | Aufbauschicht | Tragschicht | Fahrbahnschicht | 671050 | 671100 | Sueden
2 x Asphalttragschicht | Asphalttragschicht | Asphalttragschicht | Aufbauschicht | Tragschicht | Fahrbahnschicht | 671100 | 671144 | Sueden
2 x Schottertragschicht | Schottertragschicht | Schottertragschicht | Aufbauschicht | Tragschicht | Fahrbahnschicht | 670958 | 671000 | Norden
2 x Schottertragschicht | Schottertragschicht | Schottertragschicht | Aufbauschicht | Tragschicht | Fahrbahnschicht | 671000 | 671050 | Norden
2 x Schottertragschicht | Schottertragschicht | Schottertragschicht | Aufbauschicht | Tragschicht | Fahrbahnschicht | 671050 | 671100 | Sueden
2 x Schottertragschicht | Schottertragschicht | Schottertragschicht | Aufbauschicht | Tragschicht | Fahrbahnschicht | 671100 | 671144 | Sueden
Schotter | Schotter | Schotter | Aufbauschicht | Frostschutzschicht | Fahrbahnschicht | 670958 | 671000 | Norden
Schotter | Schotter | Schotter | Aufbauschicht | Frostschutzschicht | Fahrbahnschicht | 671000 | 671050 | Norden
Schotter | Schotter | Schotter | Aufbauschicht | Frostschutzschicht | Fahrbahnschicht | 671050 | 671100 | Sueden
Schotter | Schotter | Schotter | Aufbauschicht | Frostschutzschicht | Fahrbahnschicht | 671100 | 671144 | Sueden
5 x Füllmassen | Füllmassen | Erde | Bankettverfuellung | - | Erdkoerper | 670958 | 671000 | Norden
5 x Füllmassen | Füllmassen | Erde | Bankettverfuellung | - | Erdkoerper | 671000 | 671050 | Norden
5 x Füllmassen | Füllmassen | Erde | Bankettverfuellung | - | Erdkoerper | 671050 | 671100 | Sueden
5 x Füllmassen | Füllmassen | Erde | Bankettverfuellung | - | Erdkoerper | 671100 | 671144 | Sueden
5 x Mutterbodenauftrag | Mutterbodenauftrag | Mutterboden | Oberboden | - | Erdkoerper | 670958 | 671000 | Norden
5 x Mutterbodenauftrag | Mutterbodenauftrag | Mutterboden | Oberboden | - | Erdkoerper | 671000 | 671050 | Norden
5 x Mutterbodenauftrag | Mutterbodenauftrag | Mutterboden | Oberboden | - | Erdkoerper | 671050 | 671100 | Sueden
5 x Mutterbodenauftrag | Mutterbodenauftrag | Mutterboden | Oberboden | - | Erdkoerper | 671100 | 671144 | Sueden
2 x MuldenVolumen | MuldenVolumen | Erde | Freihalteraum | Mulde | Raum | 670960 | 671000 | Norden
2 x MuldenVolumen | MuldenVolumen | Erde | Freihalteraum | Mulde | Raum | 671000 | 671050 | Norden
2 x MuldenVolumen | MuldenVolumen | Erde | Freihalteraum | Mulde | Raum | 671050 | 671100 | Sueden
2 x MuldenVolumen | MuldenVolumen | Erde | Freihalteraum | Mulde | Raum | 671100 | 671144 | Sueden
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670962 | 670962 | Norden | Einfache Distanzschutzplanke links | 670+962.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670964 | 670964 | Norden | Einfache Distanzschutzplanke links | 670+964.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670966 | 670966 | Norden | Einfache Distanzschutzplanke links | 670+966.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670968 | 670968 | Norden | Einfache Distanzschutzplanke links | 670+968.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670970 | 670970 | Norden | Einfache Distanzschutzplanke links | 670+970.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670972 | 670972 | Norden | Einfache Distanzschutzplanke links | 670+972.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670974 | 670974 | Norden | Einfache Distanzschutzplanke links | 670+974.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670976 | 670976 | Norden | Einfache Distanzschutzplanke links | 670+976.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670978 | 670978 | Norden | Einfache Distanzschutzplanke links | 670+978.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670980 | 670980 | Norden | Einfache Distanzschutzplanke links | 670+980.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670982 | 670982 | Norden | Einfache Distanzschutzplanke links | 670+982.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670984 | 670984 | Norden | Einfache Distanzschutzplanke links | 670+984.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670986 | 670986 | Norden | Einfache Distanzschutzplanke links | 670+986.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670988 | 670988 | Norden | Einfache Distanzschutzplanke links | 670+988.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670990 | 670990 | Norden | Einfache Distanzschutzplanke links | 670+990.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670992 | 670992 | Norden | Einfache Distanzschutzplanke links | 670+992.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670994 | 670994 | Norden | Einfache Distanzschutzplanke links | 670+994.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670996 | 670996 | Norden | Einfache Distanzschutzplanke links | 670+996.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670998 | 670998 | Norden | Einfache Distanzschutzplanke links | 670+998.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671000 | 671000 | Norden | Einfache Distanzschutzplanke links | 671+000.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671002 | 671002 | Norden | Einfache Distanzschutzplanke links | 671+002.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671004 | 671004 | Norden | Einfache Distanzschutzplanke links | 671+004.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671006 | 671006 | Norden | Einfache Distanzschutzplanke links | 671+006.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671008 | 671008 | Norden | Einfache Distanzschutzplanke links | 671+008.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671010 | 671010 | Norden | Einfache Distanzschutzplanke links | 671+010.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671012 | 671012 | Norden | Einfache Distanzschutzplanke links | 671+012.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671014 | 671014 | Norden | Einfache Distanzschutzplanke links | 671+014.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671016 | 671016 | Norden | Einfache Distanzschutzplanke links | 671+016.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671018 | 671018 | Norden | Einfache Distanzschutzplanke links | 671+018.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671020 | 671020 | Norden | Einfache Distanzschutzplanke links | 671+020.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671022 | 671022 | Norden | Einfache Distanzschutzplanke links | 671+022.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671024 | 671024 | Norden | Einfache Distanzschutzplanke links | 671+024.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671026 | 671026 | Norden | Einfache Distanzschutzplanke links | 671+026.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671028 | 671028 | Norden | Einfache Distanzschutzplanke links | 671+028.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671030 | 671030 | Norden | Einfache Distanzschutzplanke links | 671+030.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671032 | 671032 | Norden | Einfache Distanzschutzplanke links | 671+032.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671034 | 671034 | Norden | Einfache Distanzschutzplanke links | 671+034.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671036 | 671036 | Norden | Einfache Distanzschutzplanke links | 671+036.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671038 | 671038 | Norden | Einfache Distanzschutzplanke links | 671+038.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671040 | 671040 | Norden | Einfache Distanzschutzplanke links | 671+040.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671042 | 671042 | Norden | Einfache Distanzschutzplanke links | 671+042.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671044 | 671044 | Norden | Einfache Distanzschutzplanke links | 671+044.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671046 | 671046 | Norden | Einfache Distanzschutzplanke links | 671+046.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671048 | 671048 | Norden | Einfache Distanzschutzplanke links | 671+048.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671050 | 671050 | Norden | Einfache Distanzschutzplanke links | 671+050.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671052 | 671052 | Sueden | Einfache Distanzschutzplanke links | 671+052.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671054 | 671054 | Sueden | Einfache Distanzschutzplanke links | 671+054.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671056 | 671056 | Sueden | Einfache Distanzschutzplanke links | 671+056.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671058 | 671058 | Sueden | Einfache Distanzschutzplanke links | 671+058.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671060 | 671060 | Sueden | Einfache Distanzschutzplanke links | 671+060.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671062 | 671062 | Sueden | Einfache Distanzschutzplanke links | 671+062.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671064 | 671064 | Sueden | Einfache Distanzschutzplanke links | 671+064.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671066 | 671066 | Sueden | Einfache Distanzschutzplanke links | 671+066.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671068 | 671068 | Sueden | Einfache Distanzschutzplanke links | 671+068.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671070 | 671070 | Sueden | Einfache Distanzschutzplanke links | 671+070.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671072 | 671072 | Sueden | Einfache Distanzschutzplanke links | 671+072.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671074 | 671074 | Sueden | Einfache Distanzschutzplanke links | 671+074.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671076 | 671076 | Sueden | Einfache Distanzschutzplanke links | 671+076.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671078 | 671078 | Sueden | Einfache Distanzschutzplanke links | 671+078.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671080 | 671080 | Sueden | Einfache Distanzschutzplanke links | 671+080.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671082 | 671082 | Sueden | Einfache Distanzschutzplanke links | 671+082.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671084 | 671084 | Sueden | Einfache Distanzschutzplanke links | 671+084.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671086 | 671086 | Sueden | Einfache Distanzschutzplanke links | 671+086.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671088 | 671088 | Sueden | Einfache Distanzschutzplanke links | 671+088.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671090 | 671090 | Sueden | Einfache Distanzschutzplanke links | 671+090.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671092 | 671092 | Sueden | Einfache Distanzschutzplanke links | 671+092.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671094 | 671094 | Sueden | Einfache Distanzschutzplanke links | 671+094.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671096 | 671096 | Sueden | Einfache Distanzschutzplanke links | 671+096.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671098 | 671098 | Sueden | Einfache Distanzschutzplanke links | 671+098.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671100 | 671100 | Sueden | Einfache Distanzschutzplanke links | 671+100.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671102 | 671102 | Sueden | Einfache Distanzschutzplanke links | 671+102.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671104 | 671104 | Sueden | Einfache Distanzschutzplanke links | 671+104.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671106 | 671106 | Sueden | Einfache Distanzschutzplanke links | 671+106.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671108 | 671108 | Sueden | Einfache Distanzschutzplanke links | 671+108.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671110 | 671110 | Sueden | Einfache Distanzschutzplanke links | 671+110.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671112 | 671112 | Sueden | Einfache Distanzschutzplanke links | 671+112.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671114 | 671114 | Sueden | Einfache Distanzschutzplanke links | 671+114.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671116 | 671116 | Sueden | Einfache Distanzschutzplanke links | 671+116.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671118 | 671118 | Sueden | Einfache Distanzschutzplanke links | 671+118.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671120 | 671120 | Sueden | Einfache Distanzschutzplanke links | 671+120.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671122 | 671122 | Sueden | Einfache Distanzschutzplanke links | 671+122.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671124 | 671124 | Sueden | Einfache Distanzschutzplanke links | 671+124.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671126 | 671126 | Sueden | Einfache Distanzschutzplanke links | 671+126.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671128 | 671128 | Sueden | Einfache Distanzschutzplanke links | 671+128.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671130 | 671130 | Sueden | Einfache Distanzschutzplanke links | 671+130.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671132 | 671132 | Sueden | Einfache Distanzschutzplanke links | 671+132.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671134 | 671134 | Sueden | Einfache Distanzschutzplanke links | 671+134.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671136 | 671136 | Sueden | Einfache Distanzschutzplanke links | 671+136.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671138 | 671138 | Sueden | Einfache Distanzschutzplanke links | 671+138.000
2 x Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671140 | 671140 | Sueden | Einfache Distanzschutzplanke links | 671+139.960
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670964 | 670964 | Norden | Einfache Distanzschutzplanke rechts | 670+964.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670966 | 670966 | Norden | Einfache Distanzschutzplanke rechts | 670+966.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670968 | 670968 | Norden | Einfache Distanzschutzplanke rechts | 670+968.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670970 | 670970 | Norden | Einfache Distanzschutzplanke rechts | 670+970.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670972 | 670972 | Norden | Einfache Distanzschutzplanke rechts | 670+972.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670974 | 670974 | Norden | Einfache Distanzschutzplanke rechts | 670+974.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670976 | 670976 | Norden | Einfache Distanzschutzplanke rechts | 670+976.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670978 | 670978 | Norden | Einfache Distanzschutzplanke rechts | 670+978.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670980 | 670980 | Norden | Einfache Distanzschutzplanke rechts | 670+980.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670982 | 670982 | Norden | Einfache Distanzschutzplanke rechts | 670+982.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670984 | 670984 | Norden | Einfache Distanzschutzplanke rechts | 670+984.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670986 | 670986 | Norden | Einfache Distanzschutzplanke rechts | 670+986.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670988 | 670988 | Norden | Einfache Distanzschutzplanke rechts | 670+988.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670990 | 670990 | Norden | Einfache Distanzschutzplanke rechts | 670+990.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670992 | 670992 | Norden | Einfache Distanzschutzplanke rechts | 670+992.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670994 | 670994 | Norden | Einfache Distanzschutzplanke rechts | 670+994.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670996 | 670996 | Norden | Einfache Distanzschutzplanke rechts | 670+996.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670998 | 670998 | Norden | Einfache Distanzschutzplanke rechts | 670+998.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671000 | 671000 | Norden | Einfache Distanzschutzplanke rechts | 671+000.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671002 | 671002 | Norden | Einfache Distanzschutzplanke rechts | 671+002.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671004 | 671004 | Norden | Einfache Distanzschutzplanke rechts | 671+004.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671006 | 671006 | Norden | Einfache Distanzschutzplanke rechts | 671+006.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671008 | 671008 | Norden | Einfache Distanzschutzplanke rechts | 671+008.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671010 | 671010 | Norden | Einfache Distanzschutzplanke rechts | 671+010.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671012 | 671012 | Norden | Einfache Distanzschutzplanke rechts | 671+012.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671014 | 671014 | Norden | Einfache Distanzschutzplanke rechts | 671+014.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671016 | 671016 | Norden | Einfache Distanzschutzplanke rechts | 671+016.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671018 | 671018 | Norden | Einfache Distanzschutzplanke rechts | 671+018.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671020 | 671020 | Norden | Einfache Distanzschutzplanke rechts | 671+020.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671022 | 671022 | Norden | Einfache Distanzschutzplanke rechts | 671+022.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671024 | 671024 | Norden | Einfache Distanzschutzplanke rechts | 671+024.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671026 | 671026 | Norden | Einfache Distanzschutzplanke rechts | 671+026.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671028 | 671028 | Norden | Einfache Distanzschutzplanke rechts | 671+028.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671030 | 671030 | Norden | Einfache Distanzschutzplanke rechts | 671+030.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671032 | 671032 | Norden | Einfache Distanzschutzplanke rechts | 671+032.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671034 | 671034 | Norden | Einfache Distanzschutzplanke rechts | 671+034.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671036 | 671036 | Norden | Einfache Distanzschutzplanke rechts | 671+036.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671038 | 671038 | Norden | Einfache Distanzschutzplanke rechts | 671+038.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671040 | 671040 | Norden | Einfache Distanzschutzplanke rechts | 671+040.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671042 | 671042 | Norden | Einfache Distanzschutzplanke rechts | 671+042.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671044 | 671044 | Norden | Einfache Distanzschutzplanke rechts | 671+044.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671046 | 671046 | Norden | Einfache Distanzschutzplanke rechts | 671+046.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671048 | 671048 | Norden | Einfache Distanzschutzplanke rechts | 671+048.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671050 | 671050 | Norden | Einfache Distanzschutzplanke rechts | 671+050.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671052 | 671052 | Sueden | Einfache Distanzschutzplanke rechts | 671+052.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671054 | 671054 | Sueden | Einfache Distanzschutzplanke rechts | 671+054.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671056 | 671056 | Sueden | Einfache Distanzschutzplanke rechts | 671+056.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671058 | 671058 | Sueden | Einfache Distanzschutzplanke rechts | 671+058.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671060 | 671060 | Sueden | Einfache Distanzschutzplanke rechts | 671+060.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671062 | 671062 | Sueden | Einfache Distanzschutzplanke rechts | 671+062.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671064 | 671064 | Sueden | Einfache Distanzschutzplanke rechts | 671+064.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671066 | 671066 | Sueden | Einfache Distanzschutzplanke rechts | 671+066.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671068 | 671068 | Sueden | Einfache Distanzschutzplanke rechts | 671+068.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671070 | 671070 | Sueden | Einfache Distanzschutzplanke rechts | 671+070.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671072 | 671072 | Sueden | Einfache Distanzschutzplanke rechts | 671+072.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671074 | 671074 | Sueden | Einfache Distanzschutzplanke rechts | 671+074.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671076 | 671076 | Sueden | Einfache Distanzschutzplanke rechts | 671+076.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671078 | 671078 | Sueden | Einfache Distanzschutzplanke rechts | 671+078.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671080 | 671080 | Sueden | Einfache Distanzschutzplanke rechts | 671+080.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671082 | 671082 | Sueden | Einfache Distanzschutzplanke rechts | 671+082.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671084 | 671084 | Sueden | Einfache Distanzschutzplanke rechts | 671+084.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671086 | 671086 | Sueden | Einfache Distanzschutzplanke rechts | 671+086.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671088 | 671088 | Sueden | Einfache Distanzschutzplanke rechts | 671+088.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671090 | 671090 | Sueden | Einfache Distanzschutzplanke rechts | 671+090.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671092 | 671092 | Sueden | Einfache Distanzschutzplanke rechts | 671+092.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671094 | 671094 | Sueden | Einfache Distanzschutzplanke rechts | 671+094.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671096 | 671096 | Sueden | Einfache Distanzschutzplanke rechts | 671+096.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671098 | 671098 | Sueden | Einfache Distanzschutzplanke rechts | 671+098.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671100 | 671100 | Sueden | Einfache Distanzschutzplanke rechts | 671+100.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671102 | 671102 | Sueden | Einfache Distanzschutzplanke rechts | 671+102.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671104 | 671104 | Sueden | Einfache Distanzschutzplanke rechts | 671+104.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671106 | 671106 | Sueden | Einfache Distanzschutzplanke rechts | 671+106.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671108 | 671108 | Sueden | Einfache Distanzschutzplanke rechts | 671+108.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671110 | 671110 | Sueden | Einfache Distanzschutzplanke rechts | 671+110.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671112 | 671112 | Sueden | Einfache Distanzschutzplanke rechts | 671+112.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671114 | 671114 | Sueden | Einfache Distanzschutzplanke rechts | 671+114.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671116 | 671116 | Sueden | Einfache Distanzschutzplanke rechts | 671+116.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671118 | 671118 | Sueden | Einfache Distanzschutzplanke rechts | 671+118.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671120 | 671120 | Sueden | Einfache Distanzschutzplanke rechts | 671+120.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671122 | 671122 | Sueden | Einfache Distanzschutzplanke rechts | 671+122.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671124 | 671124 | Sueden | Einfache Distanzschutzplanke rechts | 671+124.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671126 | 671126 | Sueden | Einfache Distanzschutzplanke rechts | 671+126.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671128 | 671128 | Sueden | Einfache Distanzschutzplanke rechts | 671+128.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671130 | 671130 | Sueden | Einfache Distanzschutzplanke rechts | 671+130.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671132 | 671132 | Sueden | Einfache Distanzschutzplanke rechts | 671+132.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671134 | 671134 | Sueden | Einfache Distanzschutzplanke rechts | 671+134.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671136 | 671136 | Sueden | Einfache Distanzschutzplanke rechts | 671+136.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671138 | 671138 | Sueden | Einfache Distanzschutzplanke rechts | 671+138.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671140 | 671140 | Sueden | Einfache Distanzschutzplanke rechts | 671+140.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671142 | 671142 | Sueden | Einfache Distanzschutzplanke rechts | 671+141.960
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670964 | 670964 | Norden | Einfache Distanzschutzplanke recht | 670+964.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670966 | 670966 | Norden | Einfache Distanzschutzplanke recht | 670+966.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670968 | 670968 | Norden | Einfache Distanzschutzplanke recht | 670+968.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670970 | 670970 | Norden | Einfache Distanzschutzplanke recht | 670+970.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670972 | 670972 | Norden | Einfache Distanzschutzplanke recht | 670+972.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670974 | 670974 | Norden | Einfache Distanzschutzplanke recht | 670+974.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670976 | 670976 | Norden | Einfache Distanzschutzplanke recht | 670+976.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670978 | 670978 | Norden | Einfache Distanzschutzplanke recht | 670+978.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670980 | 670980 | Norden | Einfache Distanzschutzplanke recht | 670+980.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670982 | 670982 | Norden | Einfache Distanzschutzplanke recht | 670+982.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670984 | 670984 | Norden | Einfache Distanzschutzplanke recht | 670+984.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670986 | 670986 | Norden | Einfache Distanzschutzplanke recht | 670+986.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670988 | 670988 | Norden | Einfache Distanzschutzplanke recht | 670+988.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670990 | 670990 | Norden | Einfache Distanzschutzplanke recht | 670+990.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670992 | 670992 | Norden | Einfache Distanzschutzplanke recht | 670+992.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670994 | 670994 | Norden | Einfache Distanzschutzplanke recht | 670+994.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670996 | 670996 | Norden | Einfache Distanzschutzplanke recht | 670+996.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 670998 | 670998 | Norden | Einfache Distanzschutzplanke recht | 670+998.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671000 | 671000 | Norden | Einfache Distanzschutzplanke recht | 671+000.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671002 | 671002 | Norden | Einfache Distanzschutzplanke recht | 671+002.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671004 | 671004 | Norden | Einfache Distanzschutzplanke recht | 671+004.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671006 | 671006 | Norden | Einfache Distanzschutzplanke recht | 671+006.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671008 | 671008 | Norden | Einfache Distanzschutzplanke recht | 671+008.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671010 | 671010 | Norden | Einfache Distanzschutzplanke recht | 671+010.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671012 | 671012 | Norden | Einfache Distanzschutzplanke recht | 671+012.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671014 | 671014 | Norden | Einfache Distanzschutzplanke recht | 671+014.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671016 | 671016 | Norden | Einfache Distanzschutzplanke recht | 671+016.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671018 | 671018 | Norden | Einfache Distanzschutzplanke recht | 671+018.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671020 | 671020 | Norden | Einfache Distanzschutzplanke recht | 671+020.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671022 | 671022 | Norden | Einfache Distanzschutzplanke recht | 671+022.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671024 | 671024 | Norden | Einfache Distanzschutzplanke recht | 671+024.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671026 | 671026 | Norden | Einfache Distanzschutzplanke recht | 671+026.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671028 | 671028 | Norden | Einfache Distanzschutzplanke recht | 671+028.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671030 | 671030 | Norden | Einfache Distanzschutzplanke recht | 671+030.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671032 | 671032 | Norden | Einfache Distanzschutzplanke recht | 671+032.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671034 | 671034 | Norden | Einfache Distanzschutzplanke recht | 671+034.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671036 | 671036 | Norden | Einfache Distanzschutzplanke recht | 671+036.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671038 | 671038 | Norden | Einfache Distanzschutzplanke recht | 671+038.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671040 | 671040 | Norden | Einfache Distanzschutzplanke recht | 671+040.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671042 | 671042 | Norden | Einfache Distanzschutzplanke recht | 671+042.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671044 | 671044 | Norden | Einfache Distanzschutzplanke recht | 671+044.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671046 | 671046 | Norden | Einfache Distanzschutzplanke recht | 671+046.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671048 | 671048 | Norden | Einfache Distanzschutzplanke recht | 671+048.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671050 | 671050 | Norden | Einfache Distanzschutzplanke recht | 671+050.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671052 | 671052 | Sueden | Einfache Distanzschutzplanke recht | 671+052.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671054 | 671054 | Sueden | Einfache Distanzschutzplanke recht | 671+054.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671056 | 671056 | Sueden | Einfache Distanzschutzplanke recht | 671+056.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671058 | 671058 | Sueden | Einfache Distanzschutzplanke recht | 671+058.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671060 | 671060 | Sueden | Einfache Distanzschutzplanke recht | 671+060.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671062 | 671062 | Sueden | Einfache Distanzschutzplanke recht | 671+062.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671064 | 671064 | Sueden | Einfache Distanzschutzplanke recht | 671+064.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671066 | 671066 | Sueden | Einfache Distanzschutzplanke recht | 671+066.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671068 | 671068 | Sueden | Einfache Distanzschutzplanke recht | 671+068.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671070 | 671070 | Sueden | Einfache Distanzschutzplanke recht | 671+070.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671072 | 671072 | Sueden | Einfache Distanzschutzplanke recht | 671+072.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671074 | 671074 | Sueden | Einfache Distanzschutzplanke recht | 671+074.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671076 | 671076 | Sueden | Einfache Distanzschutzplanke recht | 671+076.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671078 | 671078 | Sueden | Einfache Distanzschutzplanke recht | 671+078.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671080 | 671080 | Sueden | Einfache Distanzschutzplanke recht | 671+080.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671082 | 671082 | Sueden | Einfache Distanzschutzplanke recht | 671+082.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671084 | 671084 | Sueden | Einfache Distanzschutzplanke recht | 671+084.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671086 | 671086 | Sueden | Einfache Distanzschutzplanke recht | 671+086.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671088 | 671088 | Sueden | Einfache Distanzschutzplanke recht | 671+088.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671090 | 671090 | Sueden | Einfache Distanzschutzplanke recht | 671+090.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671092 | 671092 | Sueden | Einfache Distanzschutzplanke recht | 671+092.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671094 | 671094 | Sueden | Einfache Distanzschutzplanke recht | 671+094.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671096 | 671096 | Sueden | Einfache Distanzschutzplanke recht | 671+096.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671098 | 671098 | Sueden | Einfache Distanzschutzplanke recht | 671+098.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671100 | 671100 | Sueden | Einfache Distanzschutzplanke recht | 671+100.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671102 | 671102 | Sueden | Einfache Distanzschutzplanke recht | 671+102.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671104 | 671104 | Sueden | Einfache Distanzschutzplanke recht | 671+104.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671106 | 671106 | Sueden | Einfache Distanzschutzplanke recht | 671+106.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671108 | 671108 | Sueden | Einfache Distanzschutzplanke recht | 671+108.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671110 | 671110 | Sueden | Einfache Distanzschutzplanke recht | 671+110.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671112 | 671112 | Sueden | Einfache Distanzschutzplanke recht | 671+112.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671114 | 671114 | Sueden | Einfache Distanzschutzplanke recht | 671+114.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671116 | 671116 | Sueden | Einfache Distanzschutzplanke recht | 671+116.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671118 | 671118 | Sueden | Einfache Distanzschutzplanke recht | 671+118.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671120 | 671120 | Sueden | Einfache Distanzschutzplanke recht | 671+120.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671122 | 671122 | Sueden | Einfache Distanzschutzplanke recht | 671+122.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671124 | 671124 | Sueden | Einfache Distanzschutzplanke recht | 671+124.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671126 | 671126 | Sueden | Einfache Distanzschutzplanke recht | 671+126.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671128 | 671128 | Sueden | Einfache Distanzschutzplanke recht | 671+128.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671130 | 671130 | Sueden | Einfache Distanzschutzplanke recht | 671+130.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671132 | 671132 | Sueden | Einfache Distanzschutzplanke recht | 671+132.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671134 | 671134 | Sueden | Einfache Distanzschutzplanke recht | 671+134.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671136 | 671136 | Sueden | Einfache Distanzschutzplanke recht | 671+136.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671138 | 671138 | Sueden | Einfache Distanzschutzplanke recht | 671+138.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671140 | 671140 | Sueden | Einfache Distanzschutzplanke recht | 671+140.000
Distanzschutzplanke | Distanzschutzplanke | - | Fahrzeugrueckhaltesystem | - | Schutzeinrichtung | 671142 | 671142 | Sueden | Einfache Distanzschutzplanke recht | 671+141.960
2 x Schacht | Schacht | PolyethylenHoherDichte | Schacht | - | Entwaesserung | 671101 | 671101 | Sueden
2 x Schacht | Schacht | PolyethylenHoherDichte | Schacht | - | Entwaesserung | 671051 | 671051 | Ueberfuehrungsbereich
2 x Schacht | Schacht | PolyethylenHoherDichte | Schacht | - | Entwaesserung | 671001 | 671001 | Norden
Haltung | Haltung | - | Leitung | Rohr | Entwaesserung | 671101 | 671051 | Sueden
2 x Haltung | Haltung | PolyethylenHoherDichte | Leitung | Rohr | Entwaesserung | 671051 | 671001 | Norden
Haltung | Haltung | PolyethylenHoherDichte | Leitung | Rohr | Entwaesserung | 671001 | 670958 | Norden
Haltung | Haltung | PolyethylenHoherDichte | Leitung | Rohr | Entwaesserung | 671144 | 671101 | Sueden
Haltung | Haltung | PolyethylenHoherDichte | Leitung | Rohr | Entwaesserung | 671101 | 671051 | Sueden
Haltung | Haltung | - | Leitung | Rohr | Entwaesserung | 671001 | 670958 | Norden
Haltung | Haltung | PolyethylenHoherDichte | Leitung | Rohr | Entwaesserung | 671143 | 671101 | Sueden
