Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010, QuantityTakeOffAddOnView, SpaceBoundary1stLevelAddOnView], ExchangeRequirement[Architecture], Option [ExcludedObjects: , , , , , , , , , , , , , , , , , , , ,]
Time: 2023-03-01T12:57:13
Author: npauls
Written by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016
Made in: Autodesk Civil 3D 2022 - Deutsch (German) Build 13.4.214.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 1 12:57:13 2023 * Host: SP-20221205 * Database: C:\Users\npauls\AppData\Local\Temp\ACAIFCTMP/EDM33252\aec_ifc_db * Database version: 5507 * Database creation date: Wed Mar 1 12:56:41 2023 * Schema: IFC2X3 * Model: DataRepository.AecIfc * Model creation date: Wed Mar 1 12:57:09 2023 * Header model: DataRepository.AecIfc_Header * Header model creation date: Wed Mar 1 12:57:09 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5649 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 00000
LongName: Bohrkern
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Modell

# IfcSite
RefLatitude: 51, 9, 30, 32; RefLongitude: 12, 0, 30, 19; RefElevation: 0 m

# IfcBuilding, Bohrkern
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
BaseQuantities - Height: 0 m; NetFootprintArea: 0 m2; GrossFootprintArea: 0 m2; NetFloorArea: 0 m2; GrossFloorArea: 0 m2; GrossVolume: 0 m3

# IfcBuildingElementProxy (41)
In: Bohrkern
Lage - Abschnitt: Bundesautobahn; Bereich: Ueberfuehrungsbereich; Ebene: -; Achse: -
Bauphase - BauphaseStart: -; BauphaseEnde: -
Name | Code | Description | Thickness | Reference | Program | Objektgruppe | Objektklasse | Objekttyp | Baustoff | Bauzustand
 | Mbo | Mutterboden | 0.15 | KB01 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Mutterboden | Bestand
 | A | Auffüllung | 1.85 | KB01 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Auffüllung | Bestand
 | Gr | Kies | 2 | KB01 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Kies | Bestand
 | Cl | Ton | 0.2 | KB01 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Ton | Bestand
 | fS | Feinsand | 0.4 | KB01 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Feinsand | Bestand
 | Cl | Ton | 0.1 | KB01 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Ton | Bestand
 | mS | Mittelsand | 2.2 | KB01 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Mittelsand | Bestand
 | S | Sand | 4.1 | KB01 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Sand | Bestand
 | mS | Mittelsand | 5.3 | KB01 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Mittelsand | Bestand
 | G | Kies | 5.7 | KB01 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Kies | Bestand
 | Mbo | Mutterboden | 0.8 | KB02 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Mutterboden | Bestand
 | H | Torf, Humus | 0.2 | KB02 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Torf | Bestand
 | S | Sand | 1 | KB02 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Sand | Bestand
 | mS | Mittelsand | 3 | KB02 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Mittelsand | Bestand
 | gS | Grobsand | 3.2 | KB02 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Grobsand | Bestand
 | mG | Mittelkies | 2.8 | KB02 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Mittelkies | Bestand
 | mS | Mittelsand | 3.6 | KB02 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Mittelsand | Bestand
 | G | Kies | 6.4 | KB02 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Kies | Bestand
 | Mbo | Mutterboden | 0.6 | KB03 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Mutterboden | Bestand
 | H | Torf, Humus | 1.5 | KB03 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Torf | Bestand
 | mS | Mittelsand | 1.55 | KB03 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Mittelsand | Bestand
 | fS | Feinsand | 1.55 | KB03 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Feinsand | Bestand
 | mS | Mittelsand | 5.3 | KB03 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Mittelsand | Bestand
 | fS | Feinsand | 1.2 | KB03 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Feinsand | Bestand
 | fG | Feinkies | 3 | KB03 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Feinkies | Bestand
 | fS | Feinsand | 6.3 | KB03 | BohrkernXtension Pro | Baugrunderkundung | Bohrprofil | Kernbohrung | Feinsand | Bestand
15 x  |  |  |  |  |  | Annotation | Informationstext | - | - | -
