Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView]
File name: AdB_MuBsp_BWM_A_Gebaudemodell.ifc
Time: 2023-01-27T14:17:45
Author: npauls
Organization: thinkproject Deutschland GmbH
Written by: IFC Engine DLL
Made in: DESITE md 3.0.2
Authorization: npauls

# IfcBuildingElementProxy (13)
In: Default Building Storey
Bauphase - BauphaseEnde: -; BauphaseStart: -; Bauzustand: Bestand
Baustoff - Baustoff: -
Klassifizierung - Objektgruppe: Raum; Objekttyp: -; Objektklasse: Gebaeuderaum
Lage - Ebene: -; Achse: -; Bereich: Suedwest; Abschnitt: -
citygml - LOD: 1
Name | Type
7 x  | Building
6 x  | BuildingPart
