Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture]
Time: 2023-01-27T11:50:08
Author: npauls
Written by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016
Made in: Autodesk Civil 3D 2022 - Deutsch (German) Build 13.4.214.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 27 11:50:08 2023 * Host: SP-20221205 * Database: C:\Users\npauls\AppData\Local\Temp\ACAIFCTMP/EDM1416\aec_ifc_db * Database version: 5507 * Database creation date: Fri Jan 27 11:43:57 2023 * Schema: IFC2X3 * Model: DataRepository.AecIfc * Model creation date: Fri Jan 27 11:50:08 2023 * Header model: DataRepository.AecIfc_Header * Header model creation date: Fri Jan 27 11:50:08 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5649 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 00000
LongName: Zeichnung1
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcSite
RefElevation: 0 m

# IfcBuilding, Zeichnung1
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingElementProxy, BUILDINGELEMENTPROXY(1)
Bauphase - Bauzustand: Bestand; BauphaseStart: -; BauphaseEnde: -
Baustoff - Baustoff: -
Klassifizierung - Objektgruppe: Erdkoerper; Objektklasse: Gelaende; Objekttyp: -
Lage - Abschnitt: -; Bereich: -; Ebene: -; Achse: -
